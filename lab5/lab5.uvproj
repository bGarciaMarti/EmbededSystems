# Keil uVision project lab5.uvproj, settings and files
target Blink_LED_7Seg (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: NUC140VE3CN Nuvoton
  cpu: IRAM(0x20000000-0x20003FFF) IROM(0-0x1FFFF) CLOCK(50000000) CPUTYPE("Cortex-M0")
  output: lab5
  AfterMake: fromelf --bin ".\Objects\@L.axf" --output ".\Objects\@L.bin"
  AfterMake: fromelf --text -c ".\Objects\@L.axf" --output ".\Objects\@L.txt"
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  c include: ..\Include\Driver;..\CoreSupport;..\NUC1xx;..\Src\Driver;..\Include;..\Include\NUC1xx-LB_002
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x4000
  link misc: --map --first='startup_NUC1xx.o(RESET)' --datacompressor=off --info=inline --entry Reset_Handler
  group CMSIS
    ./: startup_NUC1xx.s
    ../CoreSupport/: core_cm0.c
    ../NUC1xx/: system_NUC1xx.c
  group Library
    ../Src/Driver/: DrvGPIO.c DrvSYS.c
    ../../Src/NUC1xx-LB_002/: Ascii_Table.C LCD_Driver.c ScanKey.c
    ../../Src/Driver/: DrvPWM.c DrvADC.c
  group Source
    ./: heartbeat.c user_func.h main.c user_func.c
